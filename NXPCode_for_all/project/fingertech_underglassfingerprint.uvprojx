# Keil uVision project fingertech_underglassfingerprint.uvprojx, settings and files
target fingertech_underglassfingerprint (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: fingertech_underglassfingerprint +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bincombined  --output  "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1,CPU_MIMXRT1052DVL6B,USB_STACK_BM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\nxplib\cmsis;..\nxplib\driver;..\nxplib\utilities;..\nxplib\xip;..\user\inc;..\nxplib\utilities\io;..\nxplib\utilities\log;..\nxplib\utilities\str;..\USB\include;..\USB\device;..\USB\osa;..\USB\phy;..\USB
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\mdk\fingertech_sdram_flexspi_nor_v1.0.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group User
    ../user/src/: board.c clock_config.c pin_mux.c FingerTech_common.c FingerTech_Exit.c FingerTech_camera.c fsl_csi_camera_adapter.c fsl_dmamux.c fsl_edma.c fsl_lpspi_edma.c FingerTech_spiConfig.c FingerTech_algorithm.c main.c FingerTech_I2C_API.c FingerTech_FlashConfig.c PIS1701.c
  group Driver
    ../nxplib/driver/: fsl_clock.c fsl_dcdc.c fsl_common.c fsl_lpspi.c fsl_lpuart.c fsl_lpi2c.c fsl_elcdif.c fsl_gpio.c fsl_csi.c fsl_cache.c fsl_flexspi.c
  group Startup
    ../nxplib/cmsis/: startup_MIMXRT1052.s
    ../nxplib/: system_MIMXRT1052.c
  group Xip
    ../nxplib/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group Utilities
    ../nxplib/utilities/io/: fsl_io.c
    ../nxplib/utilities/log/: fsl_log.c
    ../nxplib/utilities/str/: fsl_str.c
    ../nxplib/utilities/: fsl_assert.c fsl_debug_console.c
